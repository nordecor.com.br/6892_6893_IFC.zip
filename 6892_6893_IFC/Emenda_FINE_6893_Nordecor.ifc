Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-11-03T05:38:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 03 05:38:16 2025 * Host: MichellyManno * Database: C:\Users\miche\AppData\Local\Temp\69a10175-855c-467c-9222-a45240c5e119\c3d1a9a4-9e1e-4983-a1e4-1db9ad679ef9\ifc * Database version: 5507 * Database creation date: Mon Nov 03 05:38:15 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 03 05:38:16 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 03 05:38:16 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcFlowFitting: 6893, Módulo_FINE_6892_6893_Nordecor:6893:328246
In: Nível 1
Type - Material: Metal - Alumínio - Preto
Type - Cotas - Altura total da emenda: 11 mm; Comprimento da emenda: 98 mm; Largura da emenda: 98 mm
Type - Dados - Data de atualização: 25/10/2025; Versão: 1
Type - Dados de identidade - Código Uniformat: D5020.30; Comentários de tipos: emenda 90º de sobrepor na parede/reta FINE, acabamento preto, conexão elétrica angular, acessório para trilho eletrificado, sistema modular de iluminação, montagem aparente; Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Emenda 90º de sobrepor na parede/reta FINE, acabamento preto; Descrição UniFormat: Acessórios de sistemas elétricos e de iluminação; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Camboriú/SC - Brasil; Modelo: 6893; Nome do tipo: 6893; Nota-chave: 26 27 26; Número MasterFormat: 26 27 26; Número OmniClass: 23.80.70.11.14.21; Tipo de imagem: Imagem raster: 6893.png; Tipo de luminária: Não aplicável (componente elétrico sem emissão luminosa); Título MasterFormat: Acessórios para Sistemas de Trilhos de Iluminação; Título OmniClass: Spots and Tracklight Specialties; URL: https://nordecor.com.br/; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/emenda-90-de-sobrepor-parede-reta-fine/
Type - Estrutural - Peso da luminária: 0
Type - Gráficos - Simbologia: Imagem raster: 6893 2D.png
Type - Materiais e acabamentos - Módulo: Metal - Alumínio - Preto
Type - Outros - Categoria: Luminárias; Branco: no; Nome da família: Módulo_FINE_6892_6893_Nordecor; Preto: yes
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 6893; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Área: 0.00588163 m2; Volume: 0.000016479 m3
Dados de identidade - Marca: 1
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Módulo_FINE_6892_6893_Nordecor: 6893; Família e tipo: Módulo_FINE_6892_6893_Nordecor: 6893; ID de tipo: Módulo_FINE_6892_6893_Nordecor: 6893; Tipo: Módulo_FINE_6892_6893_Nordecor: 6893
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
